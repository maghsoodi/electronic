# Keil uVision project tx_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tx_project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS RTOS Validation:Framework 1.0.0, CMSIS RTOS Validation:GenWait 1.0.0, CMSIS RTOS Validation:MailQueue 1.0.0, CMSIS RTOS Validation:MemoryPool 1.0.0, CMSIS RTOS Validation:MsgQueue 1.0.0, CMSIS RTOS Validation:Mutex 1.0.0, CMSIS RTOS Validation:Semaphore 1.0.0, CMSIS RTOS Validation:Signal 1.0.0, CMSIS RTOS Validation:Thread 1.0.0, CMSIS RTOS Validation:Timer 1.0.0, CMSIS RTOS Validation:WaitFunc 1.0.0, CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX5 5.2.3, CMSIS:RTOS2:Keil RTX5 5.2.3, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:CAN 1.6.0, Device:STM32Cube HAL:CRC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:Startup 2.6.0
